# Keil uVision project bootLoader.uvprojx, settings and files
target BOOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BOOT +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: .\CORE;.\USER;.\FWLIB\inc;.\USER_CODE\board_peripheral;.\USER_CODE\BSP;.\USER_CODE\communicate;.\USER_CODE\delay;.\USER_CODE\FATFS;.\USER_CODE\ISP;.\USER_CODE\malloc;.\USER_CODE\protocol;.\USER_CODE\TIMER;.\USER_CODE\sdio_sdcard;.\USER_CODE\FATFS\exfuns;.\USER_CODE\FATFS\src;.\USER_CODE\init;.\USER_CODE\USB\STM32_USB_Device_Library\Core\inc;.\USER_CODE\USB\STM32_USB_HOST_Library\Core\inc;.\USER_CODE\USB\STM32_USB_HOST_Library\Class\HID\inc;.\USER_CODE\USB\STM32_USB_OTG_Driver\inc;.\USER_CODE\USB\USB_APP;.\USER_CODE\remote;.\USER_CODE\IAP;.\USER_CODE\flash;.\USER_CODE\USB\STM32_USB_Device_Library\Core\inc;.\USER_CODE\USB\STM32_USB_Device_Library\Class\msc\inc;.\USER_CODE\menu;.\USER_CODE\LinkQueue
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group APP
    ./USER_CODE/init/: init.c
  group CORE
    ./CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_i2c.c
  group BSP
    ./USER_CODE/BSP/: BSP_GPIO.c BSP_Timer.c bsp_usart.c BSP_PWM.c BSP_Flash.c BSP_IIC_SW.c BSP_IIC.c
  group ISP
    ./USER_CODE/ISP/: ISP_TIM.c ISP_USART.c ISP_EXIT.c
  group FATFS
    ./USER_CODE/FATFS/exfuns/: exfuns.c
    ./USER_CODE/FATFS/src/: diskio.c ff.c
    ./USER_CODE/FATFS/src/option/: cc936.c
  group SYSTEM
    ./USER_CODE/delay/: delay.c
  group MALLOC
    ./USER_CODE/malloc/: malloc.c
  group DRIVER
    ./USER_CODE/board_peripheral/: bsp_beep.c bsp_key.c bsp_led.c
    ./USER_CODE/TIMER/: timer.c
    ./USER_CODE/sdio_sdcard/: sdio_sdcard.c
    ./USER_CODE/flash/: flash.c
    ./USER_CODE/menu/: menu.c oled.c
    ./USER_CODE/LinkQueue/: LinkQueue.c
  group IAP
    ./USER_CODE/IAP/: IAP.c
  group PROTOCOL
    ../USER_CODE/protocol/: protocol.c val_data.c
  group USB_OTG
    ./USER_CODE/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_HOST
    ./USER_CODE/USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ./USER_CODE/USB/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_core.c
    ./USER_CODE/remote/: usbh_hid_remote.c
  group USB_DEVICE
    ./USER_CODE/USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./USER_CODE/USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_APP
    ./USER_CODE/USB/USB_APP/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
